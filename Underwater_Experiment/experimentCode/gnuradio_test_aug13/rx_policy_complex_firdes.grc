<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bin_number</value></param>
<param><key>value</key><value>(freq*fft_size)/samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>samp_rate/10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_name</value></param>
<param><key>value</key><value>"sendloc" + send_loc + "_trans" + trans_num + "_laketrial_aug13_2018"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>path</value></param>
<param><key>value</key><value>"/home/me/git/ft_pr/Underwater_Experiment/lake-trial-august13-2018/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>send_loc</value></param>
<param><key>value</key><value>str(3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trans_num</value></param>
<param><key>value</key><value>str(10)</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>high_cutoff_freq</key><value>1250</value></param>
<param><key>low_cutoff_freq</key><value>1150</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>2.5</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>path + "raw_complex_dat/"  + file_name + "_raw_complex.dat"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>path + file_name + ".wav"</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_size)</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
